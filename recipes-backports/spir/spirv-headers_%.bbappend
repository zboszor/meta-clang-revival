SRC_URI = "git://github.com/KhronosGroup/SPIRV-Headers;protocol=https;branch=main"
PV = "1.4.341"
SRCREV = "04f10f650d514df88b76d25e83db360142c7b174"
