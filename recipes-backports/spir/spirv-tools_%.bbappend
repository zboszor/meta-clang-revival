SRC_URI = "git://github.com/KhronosGroup/SPIRV-Tools.git;branch=main;protocol=https"
PV = "1.4.341"
SRCREV = "fbe4f3ad913c44fe8700545f8ffe35d1382b7093"
