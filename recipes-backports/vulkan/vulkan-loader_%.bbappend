SRC_URI = "git://github.com/KhronosGroup/Vulkan-Loader.git;branch=main;protocol=https"
PV = "1.4.341"
SRCREV = "32fcb949e253cbeb40cda7ea76122b492db579ae"
