SRC_URI = "git://github.com/KhronosGroup/Vulkan-Tools.git;branch=main;protocol=https"
PV = "1.4.341"
SRCREV = "48a4bcbdf619e57204783f8c1a04c76c160ddd5b"
