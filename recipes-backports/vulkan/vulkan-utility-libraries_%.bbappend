SRC_URI = "git://github.com/KhronosGroup/Vulkan-Utility-Libraries.git;branch=main;protocol=https"
PV = "1.4.341"
SRCREV = "a663eca87ba71294dd4b74ba9d3e64a72d725453"
