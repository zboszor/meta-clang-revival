SRC_URI = "git://github.com/zeux/volk.git;branch=master;protocol=https"
PV = "1.4.341"
SRCREV = "d979819fd03de3a7606d6e23d6ff4968942599da"
