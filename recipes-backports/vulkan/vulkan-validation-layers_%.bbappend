SRC_URI = "git://github.com/KhronosGroup/Vulkan-ValidationLayers.git;branch=main;protocol=https"
PV = "1.4.341"
SRCREV = "14de3c0d7b396853d81e6975aad3713984a697a6"
