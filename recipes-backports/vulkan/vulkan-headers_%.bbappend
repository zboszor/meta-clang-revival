SRC_URI = "git://github.com/KhronosGroup/Vulkan-Headers.git;branch=main;protocol=https"
PV = "1.4.341"
SRCREV = "b5c8f996196ba4aa6d8f97e52b5d3b6e70f7e4e2"
