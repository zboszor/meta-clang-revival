FILESEXTRAPATHS:prepend := "${THISDIR}/llvm-project-source:"

SRC_URI += "file://0001-spirv-version-and-extensions.patch"
